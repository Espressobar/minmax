# Keil uVision project application_keil5.uvprojx, settings and files
target Internal flash and NOR (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: application +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ST STM32F469xx USE_OS_SYSTICK USE_BPP=24 USE_FREERTOS_8
  c include: ..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\platform\os;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\framework\include;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\board\ST\STM32469I-DISCO\include;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\board\ST\STM32469I-DISCO\include\bsp;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\board\ST\STM32469I-DISCO\source\vendor\STM32469I-Discovery;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\os\FreeRTOS8.2.0\Source\include;..\..\..\..\..\touchgfx-release-4.6.0-full\touchgfx\os\FreeRTOS8.2.0\Source\portable\RVDS\ARM_CM4F;..\..\..\..\target
  asm define: USE_BPP=24
  asm include: ..\..\..\..\platform\os
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Flash.sct
  group Startup
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/Keil/: startup_stm32f469xx.s
    ../../../: main.cpp
  group Gui
    ../../../../gui/src/common/: FrontendApplication.cpp BasePresenter.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/splash_screen/: SplashPresenter.cpp SplashView.cpp
    ../../../../gui/src/idle_screen/: IdlePresenter.cpp IdleView.cpp
  group Generated
    ../../../../generated/images/src/: BitmapDatabase.cpp front_page_background_alt.cpp logo2.cpp
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp LanguageGb.cpp
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_SPLAEB___TTF_22_4bpp.cpp Font_Underwater_Love_22_4bpp.cpp FontGetters.cpp Kerning_SPLAEB___TTF_22_4bpp.cpp Kerning_Underwater_Love_22_4bpp.cpp Table_SPLAEB___TTF_22_4bpp.cpp Table_Underwater_Love_22_4bpp.cpp
  group TouchGFXHAL
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/board/ST/STM32469I-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/board/ST/STM32469I-DISCO/source/bsp/: OTM8009TouchController.cpp
    ../../../: bsp_ngdf_uart.c
  group HAL
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/board/ST/STM32469I-DISCO/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/board/ST/STM32469I-DISCO/source/vendor/Components/ft6x06/: ft6x06.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/board/ST/STM32469I-DISCO/source/vendor/Components/otm8009a/: otm8009a.c
  group OS
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/os/FreeRTOS8.2.0/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
  group Lib
    ../../../../../touchgfx-release-4.6.0-full/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 5.0.0
